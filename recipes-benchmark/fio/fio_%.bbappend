# mips doesn't support NUMA
PACKAGECONFIG_NUMA_mips = ""
PACKAGECONFIG_NUMA_mipsel = ""

